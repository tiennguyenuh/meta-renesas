DEPENDS:remove = "vspmif-user-module"
RDEPENDS:packagegroup-multimedia-libs:remove= " \
    vspmif-user-module \
"
