DEPENDS:remove = "kernel-module-vspmif"
RDEPENDS:packagegroup-multimedia-kernel-modules:remove = " \
    kernel-module-vspmif \
"

