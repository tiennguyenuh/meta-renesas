FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

RRECOMMENDS:${PN}:remove = "${PERF}"
