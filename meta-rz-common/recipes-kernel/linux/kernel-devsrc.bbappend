INSANE_SKIP:${PN} += "arch"
RDEPENDS:${PN} += "gawk"
