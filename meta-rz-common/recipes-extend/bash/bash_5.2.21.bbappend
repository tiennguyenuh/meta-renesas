# Comment all of these lines due to MULTIPLE PACKAGES error when build scarthgap
#PACKAGES += "${PN}-bashbug"
#FILES:${PN} = "${bindir}/bash ${base_bindir}/bash.bash"
#FILES:${PN}-bashbug = "${bindir}/bashbug"
